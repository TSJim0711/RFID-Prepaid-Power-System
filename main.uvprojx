# Keil uVision project main.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=161,188
  c include: .\RTE\Device\STM32F407ZE;.\demos;.\src;.\examples;.\examples\porting;.\;.\hardware;.\hardware\system
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group lvgl_porting
    ./examples/porting/: lv_port_disp.c lv_port_indev.c
  group lvgl_config
    ./: lv_conf.h
  group hardware
    ./hardware/lcd/: tft.c tft_touch.c
    ./hardware/lcd_small/: tft_small.c
    ./hardware/btn/: button.c
    ./hardware/led/: led.c
    ./hardware/system/: sys.c
    ./hardware/system/usart/: usart.c
    ./hardware/system/tim/: tim.c
    ./hardware/system/delay/: delay.c
    ./hardware/oled_small/: oled.c
    ./hardware/system/i2c/: i2c.c
    ./hardware/rfid/: MFRC522.c
  group theAPP
    ./: main.c
    ./ui/: ui_add_value.c ui_register.c
  group lvgl_src
    src/: lv_init.c
    src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    src/debugging/monkey/: lv_monkey.c
    src/debugging/sysmon/: lv_sysmon.c
    src/debugging/test/: lv_test_display.c lv_test_fs.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    src/debugging/vg_lite_tvg/: vg_lite_matrix.c
    src/display/: lv_display.c
    src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    src/draw/convert/: lv_draw_buf_convert.c
    src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
    src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
    src/draw/nanovg/: lv_draw_nanovg.c lv_draw_nanovg_3d.c lv_draw_nanovg_arc.c lv_draw_nanovg_border.c lv_draw_nanovg_box_shadow.c lv_draw_nanovg_fill.c lv_draw_nanovg_grad.c lv_draw_nanovg_image.c lv_draw_nanovg_label.c lv_draw_nanovg_layer.c lv_draw_nanovg_line.c lv_draw_nanovg_mask_rect.c lv_draw_nanovg_triangle.c lv_draw_nanovg_vector.c lv_nanovg_fbo_cache.c lv_nanovg_image_cache.c lv_nanovg_utils.c
    src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
    src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    src/draw/opengles/: lv_draw_opengles.c
    src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    src/draw/sdl/: lv_draw_sdl.c
    src/draw/snapshot/: lv_snapshot.c
    src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_bitmap_font_cache.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm_common.c lv_linux_drm_egl.c
    src/drivers/display/fb/: lv_linux_fbdev.c
    src/drivers/display/ft81x/: lv_ft81x.c
    src/drivers/display/ili9341/: lv_ili9341.c
    src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    src/drivers/display/nv3007/: lv_nv3007.c
    src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c
    src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    src/drivers/display/st7735/: lv_st7735.c
    src/drivers/display/st7789/: lv_st7789.c
    src/drivers/display/st7796/: lv_st7796.c
    src/drivers/display/st_ltdc/: lv_st_ltdc.c
    src/drivers/draw/eve/: lv_draw_eve_display.c
    src/drivers/evdev/: lv_evdev.c
    src/drivers/libinput/: lv_libinput.c lv_xkb.c
    src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_mouse.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    src/drivers/opengles/: lv_opengles_debug.c lv_opengles_driver.c lv_opengles_egl.c lv_opengles_glfw.c lv_opengles_texture.c
    src/drivers/opengles/assets/: lv_opengles_shader.c
    src/drivers/opengles/glad/src/: egl.c gl.c gles2.c
    src/drivers/opengles/opengl_shader/: lv_opengl_shader_manager.c lv_opengl_shader_program.c
    src/drivers/qnx/: lv_qnx.c
    src/drivers/sdl/: lv_sdl_egl.c lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_sw.c lv_sdl_texture.c lv_sdl_window.c
    src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
    src/drivers/wayland/: lv_wayland.c lv_wl_egl_backend.c lv_wl_g2d_backend.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_seat.c lv_wl_shm_backend.c lv_wl_touch.c lv_wl_window.c lv_wl_xdg_shell.c
    src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    src/font/binfont_loader/: lv_binfont_loader.c
    src/font/fmt_txt/: lv_font_fmt_txt.c
    src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    src/font/imgfont/: lv_imgfont.c
    src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    src/layouts/: lv_layout.c
    src/layouts/flex/: lv_flex.c
    src/layouts/grid/: lv_grid.c
    src/libs/barcode/: code128.c lv_barcode.c
    src/libs/bin_decoder/: lv_bin_decoder.c
    src/libs/bmp/: lv_bmp.c
    src/libs/ffmpeg/: lv_ffmpeg.c
    src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    src/libs/frogfs/src/: decomp_raw.c frogfs.c
    src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    src/libs/gif/: gif.c
    src/libs/gltf/gltf_environment/: lv_gltf_ibl_sampler.c
    src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    src/libs/gltf/math/: lv_3dmath.c
    src/libs/gstreamer/: lv_gstreamer.c
    src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    src/libs/libpng/: lv_libpng.c
    src/libs/libwebp/: lv_libwebp.c
    src/libs/lodepng/: lodepng.c lv_lodepng.c
    src/libs/lz4/: lz4.c
    src/libs/nanovg/: nanovg.c
    src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    src/libs/rle/: lv_rle.c
    src/libs/rlottie/: lv_rlottie.c
    src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    src/libs/tiny_ttf/: lv_tiny_ttf.c
    src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c
    src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
    src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    src/misc/cache/: lv_cache.c lv_cache_entry.c
    src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    src/others/file_explorer/: lv_file_explorer.c
    src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    src/others/translation/: lv_translation.c
    src/stdlib/: lv_mem.c
    src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    src/stdlib/micropython/: lv_mem_core_micropython.c
    src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    src/stdlib/uefi/: lv_mem_core_uefi.c
    src/themes/: lv_theme.c
    src/themes/default/: lv_theme_default.c
    src/themes/mono/: lv_theme_mono.c
    src/themes/simple/: lv_theme_simple.c
    src/tick/: lv_tick.c
    src/widgets/3dtexture/: lv_3dtexture.c
    src/widgets/animimage/: lv_animimage.c
    src/widgets/arc/: lv_arc.c
    src/widgets/arclabel/: lv_arclabel.c
    src/widgets/bar/: lv_bar.c
    src/widgets/button/: lv_button.c
    src/widgets/buttonmatrix/: lv_buttonmatrix.c
    src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    src/widgets/canvas/: lv_canvas.c
    src/widgets/chart/: lv_chart.c
    src/widgets/checkbox/: lv_checkbox.c
    src/widgets/dropdown/: lv_dropdown.c
    src/widgets/gif/: lv_gif.c
    src/widgets/image/: lv_image.c
    src/widgets/imagebutton/: lv_imagebutton.c
    src/widgets/ime/: lv_ime_pinyin.c
    src/widgets/keyboard/: lv_keyboard.c
    src/widgets/label/: lv_label.c
    src/widgets/led/: lv_led.c
    src/widgets/line/: lv_line.c
    src/widgets/list/: lv_list.c
    src/widgets/lottie/: lv_lottie.c
    src/widgets/menu/: lv_menu.c
    src/widgets/msgbox/: lv_msgbox.c
    src/widgets/objx_templ/: lv_objx_templ.c
    src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    src/widgets/roller/: lv_roller.c
    src/widgets/scale/: lv_scale.c
    src/widgets/slider/: lv_slider.c
    src/widgets/span/: lv_span.c
    src/widgets/spinbox/: lv_spinbox.c
    src/widgets/spinner/: lv_spinner.c
    src/widgets/switch/: lv_switch.c
    src/widgets/table/: lv_table.c
    src/widgets/tabview/: lv_tabview.c
    src/widgets/textarea/: lv_textarea.c
    src/widgets/tileview/: lv_tileview.c
    src/widgets/win/: lv_win.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:FSMC 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
